SUMMARY = "Kernel driver module for TI ads1298 medical ADC"
require kernel-module-topic.inc
SRCREV = "8f0b09eb778d403a497e0f5b9c2188a531bf2e1f"
