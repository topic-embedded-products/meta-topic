require kernel-module-topic.inc
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://core/rtw_io.c;beginline=2;endline=8;md5=cd30f5806fdd68c2d204b403e8fef4f2"

PV = "5.9.0.1+${SRCPV}"
PKGV = "5.9.0.1+${GITPKGV}"

SRCREV = "3a543cf227dfd0a5fa4c0ced3be0c38203dda091"
