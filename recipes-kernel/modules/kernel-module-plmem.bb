SUMMARY = "Kernel driver module for PL memory and AXI register access"
require kernel-module-topic.inc

LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRCREV = "b51c446a5aa411726faf560972cc15eaec5ee48b"
