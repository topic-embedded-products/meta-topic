
SRC_URI[tdkzu6.sha256sum] = "a1affa4de570ad8eea29a03d78a20fe1440e8a6870cab8e48fc691c1adfc6dc2"
SRC_URI[tdkzu9.sha256sum] = "cf727970195b97640f2b77f1e64128cc11678da579d0a11e0a52e0956c4a56bd"
SRC_URI[tdkzu15.sha256sum] = "3fd9594954d9683f9505dcdae60bfe7565a496c6bd99470c275d996db0a60a37"
SRC_URI[tdpzu9.sha256sum] = "008a738ed47618b423b51265e5a81a53567c014004cba19f01c9a638332f402b"
SRC_URI[tepzu9.sha256sum] = "${TOPIC_XSA_DESIGN_SHA256SUM}"
