require dtb-overlay.inc

SUMMARY = "Devicetree overlay for Topic Miami Lite Florida GEN board"

BITSTREAM_tdkz10 = "fpga-image-tdkzl-reference"
BITSTREAM_tdkz07 = "fpga-image-tdkzl-reference"

COMPATIBLE_MACHINE = "^tdkz"
