require dtb-overlay.inc

SUMMARY = "Devicetree overlay for tdkz10 board"

BITSTREAM_tdkz10 = "fpga-image-tdk-reference"

COMPATIBLE_MACHINE = "^tdkz10"
