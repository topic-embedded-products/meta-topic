# Use UART1 for console etc
ATF_CONSOLE_topic-miamimp-xilinx-xdp = "cadence1"
