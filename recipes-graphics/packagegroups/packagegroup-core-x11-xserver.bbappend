XSERVER_ADDITIONAL ?= " xf86-video-modesetting"
XSERVER:append:topic-miamimp = "${XSERVER_ADDITIONAL}"
XSERVER:append:topic-miami = "${XSERVER_ADDITIONAL}"
XSERVER:append:xdpzu7 = "${XSERVER_ADDITIONAL}"

