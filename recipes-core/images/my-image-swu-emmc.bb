BASENAME = "my"

require swu-image-emmc-AB-partitions.inc
