
IMAGE_INSTALL += "\
	kernel-modules \
	fpga-image \
	adi-hdmi-load \
	"
