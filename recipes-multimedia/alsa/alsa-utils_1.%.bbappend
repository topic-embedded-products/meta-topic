# Prevent alsa-utils dragging in udev
PACKAGECONFIG = ""
